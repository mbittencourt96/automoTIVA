# IAR project Firmware.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C1294NCPDT; UART_BUFFERED
  ICCARM.CCIncludePath2: C:\Users\menin\Local Documents\TivaWare_C_Series-2.2.0.295
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: Firmware.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group library
    ../../../../TivaWare_C_Series-2.2.0.295/driverlib/ewarm/Exe/: driverlib.a
  group source
    source/: canUtil.c canUtil.h dataStore.c dataStore.h gps.c gps.h gsm.c gsm.h main.c rgb.c rgb.h rtc.c rtc.h timer_systick.c timer_systick.h uart.c uart.h
    ./: startup_ewarm.c
